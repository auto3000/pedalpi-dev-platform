FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-configure-fix-chmod-w-issue-on-Azure-pipeline.patch"

