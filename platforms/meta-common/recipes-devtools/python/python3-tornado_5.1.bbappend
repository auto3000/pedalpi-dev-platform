
# Requires _compression which is currently located in misc
RDEPENDS_${PN} += "\
    ${PYTHON_PN}-asyncio \
    "
