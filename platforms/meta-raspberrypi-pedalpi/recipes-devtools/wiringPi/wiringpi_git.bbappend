# The official mirror disappear, this unofficial mirror remains

SRC_URI = "git://github.com/WiringPi/WiringPi.git \
           file://0001-Add-initial-cross-compile-support.patch \
           file://0001-include-asm-ioctl.h-directly-for-_IOC_SIZEBITS.patch \
           "

